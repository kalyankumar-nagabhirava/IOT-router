dirs755_append = " /opt/iotivity"
