# Copyright (C) 2016 kalyan kumar <kalyankumar.nagabhirava@gmail.com>
# Released under the apache license (see COPYING for the terms)

DESCRIPTION = "iotivity Packagegroup"
LICENSE = "APACHE2.0"

inherit packagegroup

PACKAGES = "\
    packagegroup-iotivity \
"

RDEPENDS_packagegroup-iotivity = "\
    iotivity \
"
